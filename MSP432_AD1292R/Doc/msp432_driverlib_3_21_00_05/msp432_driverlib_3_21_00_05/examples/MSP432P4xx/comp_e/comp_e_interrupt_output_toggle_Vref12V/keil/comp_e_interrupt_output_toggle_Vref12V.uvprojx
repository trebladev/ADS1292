# Keil uVision project comp_e_interrupt_output_toggle_Vref12V.uvprojx, settings and files
target comp_e_interrupt_output_toggle_Vref12V (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: comp_e_interrupt_output_toggle_Vref12V
  AfterMake: fromelf --bin --output .\Build\comp_e_interrupt_output_toggle_Vref12V.bin .\Build\comp_e_interrupt_output_toggle_Vref12V.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ../../../../../driverlib/MSP432P4xx/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: comp_e_interrupt_output_toggle_Vref12V.c
  group Library
    ../../../../../driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.2

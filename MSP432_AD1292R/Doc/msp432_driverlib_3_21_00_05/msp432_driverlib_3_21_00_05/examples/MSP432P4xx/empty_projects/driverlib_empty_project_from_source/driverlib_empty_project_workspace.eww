<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\driverlib_empty_project_from_source.ewp</path>
  </project>
  <batchBuild/>
</workspace>



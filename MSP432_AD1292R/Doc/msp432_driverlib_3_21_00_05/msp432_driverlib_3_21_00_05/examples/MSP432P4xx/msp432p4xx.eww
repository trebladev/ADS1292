<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc14\adc14_multiple_channel_no_repeat\adc14_multiple_channel_no_repeat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_channel_external_reference\adc14_single_channel_external_reference.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_channel_temperature_sensor\adc14_single_channel_temperature_sensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_comp_window_interrupt\adc14_single_comp_window_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_conversion_repeat\adc14_single_conversion_repeat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_conversion_repeat_timera_source\adc14_single_conversion_repeat_timera_source.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc14\adc14_single_differntial_2s_compliment\adc14_single_differntial_2s_compliment.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes256\aes256_encrypt_decrypt\aes256_encrypt_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_e\comp_e_interrupt_output_toggle_Vref12V\comp_e_interrupt_output_toggle_Vref12V.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_e\comp_e_output_toggle_Vcomp_Vref2V\comp_e_output_toggle_Vcomp_Vref2V.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_e\comp_e_output_toggle_Vcomp_VrefHalfVcc\comp_e_output_toggle_Vcomp_VrefHalfVcc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\crc32\crc32_16-bit_signature_calculation\crc32_16-bit_signature_calculation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\crc32\crc32_32-bit_signature_calculation\crc32_32-bit_signature_calculation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cs\cs_clock_source_init\cs_clock_source_init.ewp</path>
  </project>
    <project>
    <path>$WS_DIR$\cs\cs_dco_frequency_tune\cs_dco_frequency_tune.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cs\cs_hfxt_start\cs_hfxt_start.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cs\cs_lfxt_start\cs_lfxt_start.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cs\cs_reference_oscillator\cs_reference_oscillator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma\dma_aes256_ecb_encrypt_decrypt\dma_aes256_ecb_encrypt_decrypt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma\dma_array_transfer_software_trigger\dma_array_transfer_software_trigger.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma\dma_crc32_transfer_calculation\dma_crc32_transfer_calculation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma\dma_eusci_i2c_loopback\dma_eusci_i2c_loopback.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dma\dma_eusci_spi_loopback\dma_eusci_spi_loopback.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\flash\flash_mass_erase\flash_mass_erase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\flash\flash_program_memory\flash_program_memory.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fpu\fpu_simple_floating_point_operation\fpu_simple_floating_point_operation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio\gpio_input_interrupt\gpio_input_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio\gpio_toggle_output\gpio_toggle_output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_rw_repeated_start-master_code\i2c_master_rw_repeated_start-master_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_rw_repeated_start-slave_code\i2c_master_rw_repeated_start-slave_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_w_multibyte_multislave-master_code\i2c_master_w_multibyte_multislave-master_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_w_multibyte_multislave-slave_code\i2c_master_w_multibyte_multislave-slave_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_w_multibyte-master_code\i2c_master_w_multibyte-master_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_master_w_multibyte-slave_code\i2c_master_w_multibyte-slave_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_slave_initiated_read-master_code\i2c_slave_initiated_read-master_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c\i2c_slave_initiated_read-slave_code\i2c_slave_initiated_read-slave_code.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupt\interrupt_changing_priorities\interrupt_changing_priorities.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupt\interrupt_priority_masking\interrupt_priority_masking.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupt\interrupt_software_pending\interrupt_software_pending.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu\mpu_region_set_fault_interrupt\mpu_region_set_fault_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pcm\pcm_lpm45_no_wakeup\pcm_lpm45_no_wakeup.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pcm\pcm_go_to_lpm3\pcm_go_to_lpm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pcm\pcm_lpm35_rtc_wakeup\pcm_lpm35_rtc_wakeup.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pcm\pcm_power_state_change\pcm_power_state_change.ewp</path>
  </project>
 <project>
    <path>$WS_DIR$\pmap\pmap_timera_redirection\pmap_timera_redirection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pss\pss_high_enable_disable\pss_high_enable_disable.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rtc_c\rtc_c_calendar_alarm_interrupt\rtc_c_calendar_alarm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\spi\spi_3wire_incrementing_data-master\spi_3wire_incrementing_data-master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\spi\spi_3wire_incrementing_data-slave\spi_3wire_incrementing_data-slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\resetctl\resetctl_software_initiated_reset\resetctl_software_initiated_reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sysctl\sysctl_disable_sram_bank\sysctl_disable_sram_bank.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sysctl\sysctl_get_sram_flash_size\sysctl_get_sram_flash_size.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\systick\systick_interrupt_gpio_blink\systick_interrupt_gpio_blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer32\timer32_one_shot_free_run\timer32_one_shot_free_run.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer32\timer32_periodic_mode_led_toggle\timer32_periodic_mode_led_toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_a\timer_a_continuous_overflow_interrupt\timer_a_continuous_overflow_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_a\timer_a_continuous_vlo_period_capture\timer_a_continuous_vlo_period_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_a\timer_a_pwm_mode\timer_a_pwm_mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer_a\timer_a_updown_compare_multiple_pwm\timer_a_updown_compare_multiple_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart\uart_loopback_24mhz_brclk\uart_loopback_24mhz_brclk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart\uart_pc_echo_12mhz_brclk\uart_pc_echo_12mhz_brclk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wdt_a\wdt_a_interval_mode\wdt_a_interval_mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wdt_a\wdt_a_service_the_dog\wdt_a_service_the_dog.ewp</path>
  </project>
  <batchBuild/>
</workspace>



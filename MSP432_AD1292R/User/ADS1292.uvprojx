# Keil uVision project ADS1292.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADS1292 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__,ARM_MATH_CM4
  c include: ..\Lib\inc\CMSIS\Include;..\Lib\driverlib\MSP432P4xx;..\Lib\inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ./: main.c
  group Lib
    ../Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Startup
    ./RTE/Device/MSP432P401R/: startup_msp432p401r_uvision.s system_msp432p401r.c
  group Sys
    ../Sys/: sys.c
  group Inc
    ../Inc/: delay.h sys.h usart.h
  group Src
    ../Src/: delay.c usart.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
